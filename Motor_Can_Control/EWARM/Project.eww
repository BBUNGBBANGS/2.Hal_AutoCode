<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Motor_Can_Control.ewp</path>
  </project>
  <batchBuild />
</workspace>
